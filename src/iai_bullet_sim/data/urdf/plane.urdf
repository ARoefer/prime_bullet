Commit message: Removed reference to unknown pbsbtest package

File: src/iai_bullet_sim/data/urdf/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=30 30 10; visual box size=30 30 0.05
